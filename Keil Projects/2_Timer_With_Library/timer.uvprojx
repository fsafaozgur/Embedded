# Keil uVision project timer.uvprojx, settings and files
target Target 1 (6210000::V6.21::ARMCLANG)
  device: STM32F407VG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: timer +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: STM32F40_41xxx, USE_STDPERIPH_DRIVER, HSE_VALUE=8000000
  c include: ..\Timer_With_Library;.\inc;.\RTE\Device\STM32F407VG
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group 1
    ./: main.c bsp.c bsp.h
  group lib
    ./inc/: stm32f4xx.h stm32f4xx_conf.h stm32f4xx_gpio.c stm32f4xx_gpio.h stm32f4xx_rcc.c stm32f4xx_rcc.h stm32f4xx_syscfg.c stm32f4xx_syscfg.h stm32f4xx_tim.c stm32f4xx_tim.h system_stm32f4xx.h misc.c misc.h
software components: CMSIS:CORE 6.0.0, Device:Startup 2.1.0
